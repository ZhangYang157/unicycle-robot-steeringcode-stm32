# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F767VITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F767xx,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\procession;..\HARDWARE\gyro;..\HARDWARE\encoder;..\HARDWARE\IIC_HD;..\HARDWARE\JY901;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\IIC_HD_right;..\HARDWARE\dma;..\HARDWARE\ground;..\HARDWARE\time_interrupt;..\HARDWARE\adaptive_controller
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: startup_stm32f767xx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/JY901/: JY901.c
    ../HARDWARE/IIC_HD/: IIC_HD.c
    ../HARDWARE/procession/: procession.c
    ../HARDWARE/gyro/: gyro.c
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC_HD_right/: IIC_HD_right.c
    ../HARDWARE/dma/: dma.c
    ../HARDWARE/ground/: ground.c
    ../HARDWARE/time_interrupt/: time_interrpt.c
    ../HARDWARE/adaptive_controller/: adaptive_controller.c
  group README
    ../: readme.txt
